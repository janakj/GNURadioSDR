<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.11'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>p25_c4fm_demodulator_ff</value></param>
<param><key>category</key><value>P25</value></param>
<param><key>generate_options</key><value>hb</value></param>
<param><key>title</key><value>C4FM Demodulator</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>auto_tune_msgq</value></param>
<param><key>value</key><value>gr.msg_queue(2)</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>import p25</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>input_rate</value></param>
<param><key>label</key><value>Input Rate</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>48000</value></param>
</block>
<block>
<key>op25_fsk4_demod_ff</key>
<param><key>id</key><value>op25_fsk4_demod_ff_0</value></param>
<param><key>tune_out</key><value>True</value></param>
<param><key>sample_rate</key><value>input_rate</value></param>
<param><key>symbol_rate</key><value>output_rate</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>output_rate</value></param>
<param><key>label</key><value>Output Rate</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>4800</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>label</key><value>output</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>pad_source_0</value></param>
<param><key>label</key><value>input</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>fir_filter_xxx</key>
<param><key>id</key><value>symbol_filter</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>taps</key><value>p25.generate_c4fm_taps(output_rate, input_rate, span=9, tx=False)</value></param>
<param><key>type</key><value>fff</value></param>
</block>
<connection><source_block_id>op25_fsk4_demod_ff_0</source_block_id><sink_block_id>pad_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pad_source_0</source_block_id><sink_block_id>symbol_filter</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>symbol_filter</source_block_id><sink_block_id>op25_fsk4_demod_ff_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
