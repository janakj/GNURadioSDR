<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.11'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>p25_symbol_mapper_fb</value></param>
<param><key>category</key><value>P25</value></param>
<param><key>generate_options</key><value>hb</value></param>
<param><key>title</key><value>Symbol Demapper</value></param>
</block>
<block>
<key>op25_fsk4_slicer_fb</key>
<param><key>id</key><value>op25_fsk4_slicer_fb_0</value></param>
<param><key>threshold1</key><value>-2.0</value></param>
<param><key>threshold2</key><value>0.0</value></param>
<param><key>threshold3</key><value>2.0</value></param>
<param><key>threshold4</key><value>4.0</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>label</key><value>out</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>pad_source_0</value></param>
<param><key>label</key><value>in</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>threshold1</value></param>
<param><key>label</key><value>Threshold 1</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>-2</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>threshold2</value></param>
<param><key>label</key><value>Threshold 2</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>threshold3</value></param>
<param><key>label</key><value>Threshold 3</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>2.0</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>threshold4</value></param>
<param><key>label</key><value>Threshold 4</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>4.0</value></param>
</block>
<connection><source_block_id>op25_fsk4_slicer_fb_0</source_block_id><sink_block_id>pad_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pad_source_0</source_block_id><sink_block_id>op25_fsk4_slicer_fb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
