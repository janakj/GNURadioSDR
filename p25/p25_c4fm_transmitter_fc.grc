<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.13'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>p25_c4fm_transmitter_fc</value></param>
<param><key>category</key><value>P25</value></param>
<param><key>generate_options</key><value>hb</value></param>
<param><key>title</key><value>C4FM Transmitter</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>if_rate</value></param>
<param><key>value</key><value>48000</value></param>
</block>
<block>
<key>variable_low_pass_filter_taps</key>
<param><key>id</key><value>taps</value></param>
<param><key>cutoff_freq</key><value>12500 / 2</value></param>
<param><key>gain</key><value>output_rate / if_rate</value></param>
<param><key>samp_rate</key><value>output_rate</value></param>
<param><key>width</key><value>100</value></param>
<param><key>win</key><value>firdes.WIN_HANN</value></param>
</block>
<block>
<key>blocks_float_to_short</key>
<param><key>id</key><value>float_to_short</value></param>
<param><key>scale</key><value>32768</value></param>
</block>
<block>
<key>p25_fm_modulator_fc</key>
<param><key>id</key><value>fm_mod</value></param>
<param><key>factor</key><value>1</value></param>
<param><key>max_deviation</key><value>2.5e3</value></param>
<param><key>samp_rate</key><value>if_rate</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>from gnuradio import filter</value></param>
</block>
<block>
<key>interp_fir_filter_xxx</key>
<param><key>id</key><value>interp_fir_filter_xxx_0</value></param>
<param><key>interp</key><value>output_rate / if_rate</value></param>
<param><key>taps</key><value>taps</value></param>
<param><key>type</key><value>ccf</value></param>
</block>
<block>
<key>op25_vocoder</key>
<param><key>id</key><value>op25_vocoder_0</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>output_rate</value></param>
<param><key>label</key><value>Output Rate</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>48000</value></param>
</block>
<block>
<key>p25_c4fm_modulator_ff</key>
<param><key>id</key><value>p25_c4fm_modulator_ff_0</value></param>
<param><key>input_rate</key><value>4800</value></param>
<param><key>output_rate</key><value>if_rate</value></param>
<param><key>gain</key><value>6.0</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>label</key><value>output</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_1</value></param>
<param><key>type</key><value>float</value></param>
<param><key>label</key><value>c4fm</value></param>
<param><key>optional</key><value>True</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_3</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>label</key><value>symbols</value></param>
<param><key>optional</key><value>True</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>pad_source_0</value></param>
<param><key>label</key><value>input</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>p25_symbol_mapper_bf</key>
<param><key>id</key><value>symbol_mapper</value></param>
<param><key>symbol00</key><value>1.0/3.0</value></param>
<param><key>symbol01</key><value>1.0</value></param>
<param><key>symbol10</key><value>-1.0/3.0</value></param>
<param><key>symbol11</key><value>-1.0</value></param>
</block>
<connection><source_block_id>float_to_short</source_block_id><sink_block_id>op25_vocoder_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fm_mod</source_block_id><sink_block_id>interp_fir_filter_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>interp_fir_filter_xxx_0</source_block_id><sink_block_id>pad_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>op25_vocoder_0</source_block_id><sink_block_id>pad_sink_3</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>op25_vocoder_0</source_block_id><sink_block_id>symbol_mapper</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>p25_c4fm_modulator_ff_0</source_block_id><sink_block_id>fm_mod</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>p25_c4fm_modulator_ff_0</source_block_id><sink_block_id>pad_sink_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pad_source_0</source_block_id><sink_block_id>float_to_short</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>symbol_mapper</source_block_id><sink_block_id>p25_c4fm_modulator_ff_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
