<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.11'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>p25_c4fm_transmitter_fc</value></param>
<param><key>category</key><value>P25</value></param>
<param><key>generate_options</key><value>hb</value></param>
<param><key>title</key><value>C4FM Transmitter</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>cutoff</value></param>
<param><key>value</key><value>2880</value></param>
</block>
<block>
<key>blocks_float_to_short</key>
<param><key>id</key><value>float_to_short</value></param>
<param><key>scale</key><value>32768</value></param>
</block>
<block>
<key>p25_fm_modulator_fc</key>
<param><key>id</key><value>fm_mod</value></param>
<param><key>factor</key><value>1.5</value></param>
<param><key>max_deviation</key><value>12.5e3</value></param>
<param><key>samp_rate</key><value>48000</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>from gnuradio import filter</value></param>
</block>
<block>
<key>interp_fir_filter_xxx</key>
<param><key>id</key><value>interpolator</value></param>
<param><key>interp</key><value>1</value></param>
<param><key>taps</key><value>filter.firdes.low_pass(1.0, 48000, cutoff, cutoff * 0.1, filter.firdes.WIN_HANN)</value></param>
<param><key>type</key><value>fff</value></param>
</block>
<block>
<key>op25_vocoder</key>
<param><key>id</key><value>op25_vocoder_0</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>output_rate</value></param>
<param><key>label</key><value>Output Rate</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>48000</value></param>
</block>
<block>
<key>p25_c4fm_modulator_ff</key>
<param><key>id</key><value>p25_c4fm_modulator_ff_0</value></param>
<param><key>input_rate</key><value>4800</value></param>
<param><key>output_rate</key><value>48000</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>label</key><value>output</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>pad_source_0</value></param>
<param><key>label</key><value>input</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>pfb_arb_resampler_xxx</key>
<param><key>id</key><value>resampler</value></param>
<param><key>nfilts</key><value>32</value></param>
<param><key>rrate</key><value>float(output_rate) / 48000</value></param>
<param><key>atten</key><value>100</value></param>
<param><key>type</key><value>ccf</value></param>
</block>
<block>
<key>p25_symbol_mapper_bf</key>
<param><key>id</key><value>symbol_mapper</value></param>
<param><key>symbol00</key><value>1.0/3.0</value></param>
<param><key>symbol01</key><value>1.0</value></param>
<param><key>symbol10</key><value>-1.0/3.0</value></param>
<param><key>symbol11</key><value>-1.0</value></param>
</block>
<connection><source_block_id>float_to_short</source_block_id><sink_block_id>op25_vocoder_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fm_mod</source_block_id><sink_block_id>resampler</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>interpolator</source_block_id><sink_block_id>fm_mod</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>op25_vocoder_0</source_block_id><sink_block_id>symbol_mapper</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>p25_c4fm_modulator_ff_0</source_block_id><sink_block_id>interpolator</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pad_source_0</source_block_id><sink_block_id>float_to_short</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>resampler</source_block_id><sink_block_id>pad_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>symbol_mapper</source_block_id><sink_block_id>p25_c4fm_modulator_ff_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
