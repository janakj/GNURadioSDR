<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.11'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>p25_arb_resampler_cc</value></param>
<param><key>category</key><value>P25</value></param>
<param><key>generate_options</key><value>hb</value></param>
<param><key>title</key><value>Arbitrary Resampler</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>decimation</value></param>
<param><key>value</key><value>int(input_rate / output_rate)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>rel_freq</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>resampled_rate</value></param>
<param><key>value</key><value>float(input_rate) / float(decimation)</value></param>
</block>
<block>
<key>pfb_arb_resampler_xxx</key>
<param><key>id</key><value>arb_resampler</value></param>
<param><key>nfilts</key><value>32</value></param>
<param><key>rrate</key><value>float(output_rate) / resampled_rate</value></param>
<param><key>atten</key><value>100</value></param>
<param><key>type</key><value>ccf</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>from gnuradio import filter</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>input_rate</value></param>
<param><key>label</key><value>Input Rate</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>48000</value></param>
</block>
<block>
<key>fir_filter_xxx</key>
<param><key>id</key><value>lpf</value></param>
<param><key>decim</key><value>decimation</value></param>
<param><key>taps</key><value>filter.firdes.low_pass(1.0, input_rate, 7250, 725, filter.firdes.WIN_HANN)</value></param>
<param><key>type</key><value>ccf</value></param>
</block>
<block>
<key>blocks_multiply_xx</key>
<param><key>id</key><value>mixer</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>analog_sig_source_x</key>
<param><key>id</key><value>osc</value></param>
<param><key>amp</key><value>1</value></param>
<param><key>freq</key><value>rel_freq</value></param>
<param><key>offset</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>samp_rate</key><value>input_rate</value></param>
<param><key>waveform</key><value>analog.GR_SIN_WAVE</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>output_rate</value></param>
<param><key>label</key><value>Output Rate</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>48000</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>label</key><value>output</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>pad_source_0</value></param>
<param><key>label</key><value>input</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<connection><source_block_id>arb_resampler</source_block_id><sink_block_id>pad_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lpf</source_block_id><sink_block_id>arb_resampler</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>mixer</source_block_id><sink_block_id>lpf</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>osc</source_block_id><sink_block_id>mixer</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>pad_source_0</source_block_id><sink_block_id>mixer</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
