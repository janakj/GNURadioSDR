<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.11'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>p25_symbol_mapper_bf</value></param>
<param><key>category</key><value>P25</value></param>
<param><key>generate_options</key><value>hb</value></param>
<param><key>title</key><value>Symbol Mapper</value></param>
</block>
<block>
<key>digital_chunks_to_symbols_xx</key>
<param><key>id</key><value>digital_chunks_to_symbols_xx_0</value></param>
<param><key>dimension</key><value>1</value></param>
<param><key>in_type</key><value>byte</value></param>
<param><key>out_type</key><value>float</value></param>
<param><key>symbol_table</key><value>(symbol00, symbol01, symbol10, symbol11)</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>label</key><value>output</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>pad_source_0</value></param>
<param><key>label</key><value>input</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>symbol00</value></param>
<param><key>label</key><value>Symbol 00</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>1.0/3.0</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>symbol01</value></param>
<param><key>label</key><value>Symbol 01</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>1.0</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>symbol10</value></param>
<param><key>label</key><value>Symbol 10</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>-1.0/3.0</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>symbol11</value></param>
<param><key>label</key><value>Symbol 11</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>-1.0</value></param>
</block>
<connection><source_block_id>digital_chunks_to_symbols_xx_0</source_block_id><sink_block_id>pad_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pad_source_0</source_block_id><sink_block_id>digital_chunks_to_symbols_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
