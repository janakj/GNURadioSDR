<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.11'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>p25_c4fm_receiver_cf</value></param>
<param><key>category</key><value>P25</value></param>
<param><key>generate_options</key><value>hb</value></param>
<param><key>title</key><value>C4FM Receiver</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>fa</value></param>
<param><key>value</key><value>6250</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>fb</value></param>
<param><key>value</key><value>fa + 0.1 * fa</value></param>
</block>
<block>
<key>p25_arb_resampler_cc</key>
<param><key>id</key><value>arb_resampler</value></param>
<param><key>input_rate</key><value>input_rate</value></param>
<param><key>output_rate</key><value>48000</value></param>
</block>
<block>
<key>fir_filter_xxx</key>
<param><key>id</key><value>cutoff</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>taps</key><value>filter.firdes.low_pass(1.0, 48000, (fa + fb) / 2, fb - fa, filter.firdes.WIN_HANN)</value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>from gnuradio import filter</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>input_rate</value></param>
<param><key>label</key><value>Input Rate</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>48000</value></param>
</block>
<block>
<key>op25_frame_assembler</key>
<param><key>id</key><value>op25_frame_assembler_0</value></param>
</block>
<block>
<key>p25_c4fm_demodulator_ff</key>
<param><key>id</key><value>p25_c4fm_demodulator_ff_0</value></param>
<param><key>input_rate</key><value>48000</value></param>
<param><key>output_rate</key><value>4800</value></param>
</block>
<block>
<key>p25_fm_demodulator_cf</key>
<param><key>id</key><value>p25_fm_demodulator_cf_0</value></param>
<param><key>samp_rate</key><value>48000</value></param>
<param><key>symbol_deviation</key><value>600.0</value></param>
</block>
<block>
<key>p25_symbol_mapper_fb</key>
<param><key>id</key><value>p25_symbol_mapper_fb_0</value></param>
<param><key>threshold1</key><value>-2</value></param>
<param><key>threshold2</key><value>0</value></param>
<param><key>threshold3</key><value>2.0</value></param>
<param><key>threshold4</key><value>4.0</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>label</key><value>out</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>pad_source_0</value></param>
<param><key>label</key><value>in</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_short_to_float</key>
<param><key>id</key><value>short_to_float</value></param>
<param><key>scale</key><value>32768</value></param>
</block>
<connection><source_block_id>arb_resampler</source_block_id><sink_block_id>cutoff</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>cutoff</source_block_id><sink_block_id>p25_fm_demodulator_cf_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>op25_frame_assembler_0</source_block_id><sink_block_id>short_to_float</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>p25_c4fm_demodulator_ff_0</source_block_id><sink_block_id>p25_symbol_mapper_fb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>p25_fm_demodulator_cf_0</source_block_id><sink_block_id>p25_c4fm_demodulator_ff_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>p25_symbol_mapper_fb_0</source_block_id><sink_block_id>op25_frame_assembler_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pad_source_0</source_block_id><sink_block_id>arb_resampler</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>short_to_float</source_block_id><sink_block_id>pad_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
