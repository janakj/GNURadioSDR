<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.12'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>p25_fm_demodulator_cf</value></param>
<param><key>category</key><value>P25</value></param>
<param><key>generate_options</key><value>hb</value></param>
<param><key>title</key><value>FM Demodulator</value></param>
</block>
<block>
<key>analog_fm_deemph</key>
<param><key>id</key><value>analog_fm_deemph_0</value></param>
<param><key>_enabled</key><value>2</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>tau</key><value>75e-6</value></param>
</block>
<block>
<key>analog_quadrature_demod_cf</key>
<param><key>id</key><value>analog_quadrature_demod_cf_0</value></param>
<param><key>gain</key><value>samp_rate / (2 * math.pi * max_deviation)</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>max_deviation</value></param>
<param><key>label</key><value>Maximum Deviation</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>2500</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>label</key><value>output</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>pad_source_0</value></param>
<param><key>label</key><value>input</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>label</key><value>Sample Rate</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>48000 * 20</value></param>
</block>
<connection><source_block_id>analog_fm_deemph_0</source_block_id><sink_block_id>pad_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_quadrature_demod_cf_0</source_block_id><sink_block_id>analog_fm_deemph_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pad_source_0</source_block_id><sink_block_id>analog_quadrature_demod_cf_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
