<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.11'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>p25_cqpsk_demodulator_cf</value></param>
<param><key>category</key><value>P25</value></param>
<param><key>generate_options</key><value>hb</value></param>
<param><key>title</key><value>CQPSK Demodulator</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>alpha</value></param>
<param><key>value</key><value>costas_alpha</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>beta</value></param>
<param><key>value</key><value>0.125 * alpha * alpha</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>fmax</value></param>
<param><key>value</key><value>2 * math.pi * 2400 / float(input_rate)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>gain_omega</value></param>
<param><key>value</key><value>0.1 * gain_mu * gain_mu</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>omega</value></param>
<param><key>value</key><value>float(input_rate) / float(output_rate)</value></param>
</block>
<block>
<key>analog_feedforward_agc_cc</key>
<param><key>id</key><value>agc</value></param>
<param><key>num_samples</key><value>16</value></param>
<param><key>reference</key><value>1.0</value></param>
</block>
<block>
<key>op25_repeater_gardner_costas_cc</key>
<param><key>id</key><value>clock</value></param>
<param><key>alpha</key><value>alpha</value></param>
<param><key>beta</key><value>beta</value></param>
<param><key>gain_mu</key><value>gain_mu</value></param>
<param><key>gain_omega</key><value>gain_omega</value></param>
<param><key>max_freq</key><value>fmax</value></param>
<param><key>min_freq</key><value>-fmax</value></param>
<param><key>samples_per_symbol</key><value>omega</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>costas_alpha</value></param>
<param><key>label</key><value>Costas Alpha</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>0.04</value></param>
</block>
<block>
<key>digital_diff_phasor_cc</key>
<param><key>id</key><value>diffdec</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>gain_mu</value></param>
<param><key>label</key><value>Gain Mu</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>0.025</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>import math</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>input_rate</value></param>
<param><key>label</key><value>Input Rate</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>48000</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>output_rate</value></param>
<param><key>label</key><value>Output Rate</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>4800</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>label</key><value>output</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>pad_source_0</value></param>
<param><key>label</key><value>input</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>rescale</value></param>
<param><key>const</key><value>1 / (math.pi / 4)</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_complex_to_arg</key>
<param><key>id</key><value>to_float</value></param>
</block>
<connection><source_block_id>agc</source_block_id><sink_block_id>clock</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>clock</source_block_id><sink_block_id>diffdec</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>diffdec</source_block_id><sink_block_id>to_float</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pad_source_0</source_block_id><sink_block_id>agc</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rescale</source_block_id><sink_block_id>pad_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>to_float</source_block_id><sink_block_id>rescale</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
